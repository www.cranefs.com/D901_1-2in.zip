# Autodesk Inventor part: D901_1-2in
## iProperties
Created: 2011-01
Part Number: D901_1-2in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
